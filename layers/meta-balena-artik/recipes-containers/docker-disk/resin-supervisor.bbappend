# common for both Artik 5 and Artik 10

LED_FILE = "/dev/null"
